# Keil uVision project TemplateProject.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: GD32H759IM GigaDevice
  pack: GigaDevice.GD32H7xx_DFP.1.4.0
  cpu: IRAM(0x24000000,0x000D0000) IRAM2(0x00000000,0x00010000) IROM(0x08000000,0x03C0000) XRAM(0x20000000,0x00020000) XRAM2(0x30000000,0x00004000) XRAM3(0x30004000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: TemplateProject
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: HXTAL_VALUE=8000000,
  c misc: --diag_suppress=68,111,188,223,546,1295
  c include: .\GD32H7xx_standard_peripheral\Include;.\GD32H7xx;.\GD32H7xx\CMSIS;.;.\Drivers;.\FATFS;.\lvgl;.\lvgl\src;.\lvgl\examples\porting;.\lvgl\demos\benchmark;.\lvgl\demos\stress;.\ui;.\ui\icon;.\ui\layouts;.\ui\widgets;.\ui\callbacks;.\modules
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3c0000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT7: RAM 0x30000000 size 0x4000
  memory RVCT8: RAM 0x30004000 size 0x4000
  memory RVCT9: RAM 0x24000000 size 0xd0000
  memory RVCT10: RAM 0x0 size 0x10000
  group MAIN
    ./: main.c gd32h7xx_it.c read_file_to_array.c
    ./GD32H7xx/: startup_gd32h7xx.s system_gd32h7xx.c
    ./lvgl/demos/benchmark/assets/: lv_font_bechmark_montserrat_12_compr_az.c.c lv_font_bechmark_montserrat_16_compr_az.c.c
  group UI
    ./UI/: ui.c ui.h icon.h
    ./ui/layouts/: ui_load.c ui_main.c ui_drone.c ui_shop.c
    ./ui/callbacks/: ui_main_cb.h ui_main_cb.c ui_drone_cb.h ui_drone_cb.c ui_shop_cb.h ui_shop_cb.c ui_window_cb.h ui_window_cb.c ui_load_cb.c ui_load_cb.h
    ./ui/: icon.c ui_common.h ui_common.c
    ./ui/widgets/: ui_grid_list.c ui_grid_list.h ui_window.c ui_window.h
  group icon
    ./UI/icon/: icon_field_bg.c
    ./ui/icon/: icon_farm_bg.c icon_gold_bar_bg.c icon_plant_btn.c icon_setting_btn.c icon_shop_btn.c icon_storage_btn.c icon_crop_corn.c icon_crop_wheat_young.c icon_crop_wheat_ripe.c icon_crop_corn_ripe.c icon_drone_0.c icon_drone_1.c icon_pest_unknown.c icon_pest_aphid.c icon_pest_leafroller.c icon_pest_locust.c icon_pest_mite.c
  group modules
    ./modules/: drone.c drone.h enum.h farm.c farm.h field.c field.h player.c player.h store.c store.h event.c event.h enum.c
  group Standard Peripheral
    ./GD32H7xx_standard_peripheral/Source/: gd32h7xx_misc.c gd32h7xx_gpio.c gd32h7xx_rcu.c gd32h7xx_tli.c gd32h7xx_exmc.c gd32h7xx_sdio.c gd32h7xx_usart.c gd32h7xx_spi.c gd32h7xx_dma.c gd32h7xx_adc.c gd32h7xx_trng.c
  group Drivers
    ./Drivers/: LCD_tli.c exmc_sdram.c sdcard.c touch_gtxx.c touch_iic.c sys.c heap_4.c joystick.h joystick.c
  group FATFS
    ./FATFS/: diskio.c ff.c ffsystem.c ffunicode.c
  group lvgl\examples\porting
    ./lvgl/examples/porting/: lv_port_disp_template.c lv_port_indev_template.c
  group lvgl\src\core
    ./lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group lvgl\src\draw
    ./lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ./lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
  group lvgl\src\extra
    ./lvgl/src/extra/layouts/flex/: lv_flex.c
    ./lvgl/src/extra/layouts/grid/: lv_grid.c
    ./lvgl/src/extra/libs/bmp/: lv_bmp.c
    ./lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ./lvgl/src/extra/libs/freetype/: lv_freetype.c
    ./lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ./lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ./lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ./lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ./lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ./lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ./lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ./lvgl/src/extra/others/monkey/: lv_monkey.c
    ./lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ./lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ./lvgl/src/extra/themes/default/: lv_theme_default.c
    ./lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ./lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ./lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ./lvgl/src/extra/widgets/chart/: lv_chart.c
    ./lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ./lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ./lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ./lvgl/src/extra/widgets/led/: lv_led.c
    ./lvgl/src/extra/widgets/list/: lv_list.c
    ./lvgl/src/extra/widgets/menu/: lv_menu.c
    ./lvgl/src/extra/widgets/meter/: lv_meter.c
    ./lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ./lvgl/src/extra/widgets/span/: lv_span.c
    ./lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ./lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ./lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ./lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ./lvgl/src/extra/widgets/win/: lv_win.c
    ./lvgl/src/extra/: lv_extra.c
  group lvgl\src\font
    ./lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group lvgl\src\gpu
    ./lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
  group lvgl\src\hal
    ./lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lvgl\src\misc
    ./lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group lvgl\src\widgets
    ./lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
